## boards/shields/nothing_mouse/Kconfig.defconfig
```kconfig
if SHIELD_NOTHING_MOUSE

config ZMK_KEYBOARD_NAME
    default "Nothing Mouse"

endif
```
